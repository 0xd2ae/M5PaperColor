## main/Kconfig.projbuild
```kconfig
menu "PaperColor calendar"
    config PC_PANEL_TEST
        bool "Display six-color hardware test instead of calendar"
        default n
endmenu
```
